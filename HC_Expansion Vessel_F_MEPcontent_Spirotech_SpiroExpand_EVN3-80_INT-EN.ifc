Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: 807fb87b-aa6f-4c89-a289-2d4037f525e4, VersionGUID: 76c1eca3-e988-465b-a7b1-b911a8db10f5, NumberOfSaves: 238]
File name: HC_Expansion Vessel_F_MEPcontent_Spirotech_SpiroExpand_EVN3-80_INT-EN.ifc
Time: 2026-09-28T11:02:11+02:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.3.40.26 (ENU) - IFC 24.3.40.26

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
V00 | V00 | 0
V01 | V01 | 3300
V02 | V02 | 6600

# IfcBuildingElementProxy: HC_Expansion Vessel_F_MEPcontent_Spirotech_SpiroExpand_EVN_INT-EN:EVN3-80, HC_Expansion Vessel_F_MEPcontent_Spirotech_SpiroExpand_EVN_INT-EN:EVN3-80:1332273
In: V00
Type - Material: Color RGB 128-128-128, Color RGB 040-040-040
Type - Other - Category: Mechanical Equipment; Arc: 33 mm; Arc Logo: 900 mm; Belt: yes; Belt Height: 193.5 mm; Bracket Height: 549.5 mm; Connection Depth: 36 mm; Distance Support: 0 mm; Family Name: HC_Expansion Vessel_F_MEPcontent_Spirotech_SpiroExpand_EVN_INT-EN; Length Support: 260 mm; M: 171 mm; Nominal Diameter: 19 mm; Outer Diameter: 26.9 mm; Q: 80 mm; Revolve Radius: 13.45 mm; S: 174 mm; Suport Visibility: no; t: 165 mm; Top Bracket: 221 mm; Top Bracket Back: no; Top Bracket Height: 22 mm; Top Bracket Visible: yes; Total Width: 640 mm; Visibility 1: no; Visibility 2: yes; Void Offset: 90.5 mm
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Diameter: 19 mm; Height: 370 mm; Use Nominal Diameter: yes; Width: 604 mm
Type - Identity Data - Article Type: EVN3-80; Base Family Version: 26.10; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: EVN-3 bar expansion vessel 80L hanging; EMCS Version: 5.0; ETIM Article Class: EC010958; Family Version: 26.10; GLN: 8717811000007; Manufacturer: Spirotech; Manufacturer URL: https://www.spirotech.com/products/spiroexpand-expansion-vessels/spiroexpand-evn-3-bar-297?variant=2134; MEPcontent Class: EXPANSIONVASSEL; Model: EVN3-80; OmniClass Number: 23.75.70.11.14; OmniClass Title: Expansion Vessels; Revit Version: 2024; Type Name: EVN3-80; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Dark Grey: Color RGB 040-040-040; Grey: Color RGB 128-128-128
Type - Mechanical - Connection Pipe Type: External thread conical BSPT-R (ISO 7-1 / EN 10226-1) (EV020238); Horizontal Positioning: Yes; Material Membrane/Bladder: IIR (butyl) (EV020568); Max.Safety Temperature: 100 C; Maximum Gas Pre-Pressure: 100000 Pa; Maximum Glycol Mixture: 50%; Maximum Medium Temperature: 70 C; Maximum Operating Pressure: 300000 Pa; Minimum Medium Temperature: -10 C; Nominal Diameter, Expansion Connection: DN 15 (EV005372); Outer Pipe Diameter, Expansion Connection: 26.4 mm; Standard Gas Presure: 1 bar; Suitable for Central Heating: yes; Suitable for Cooling: yes; Suitable for Solar Collector Circuit: yes; Suitable for Tap Water: no; Tilting Height: 648 mm; Volume: 0.08 m3; Weight: 14.5 kg; With Drain: Yes; With Exchangeable Membrane: Yes; With Fixed Wall Support: Yes; With Mounting Material: Yes; With Vessel Manifold: No
Type - Text - Article Description: EVN-3 bar expansion vessel 80L hanging; GTIN: 8717811068168; Manufacturer Art. No.: EVN3-80; Product Line: Spirotech
Type - Visibility - 1/2'': no
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_BuildingElementProxyCommon - Reference: EVN3-80; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: EVN3-80
Other - Family: HC_Expansion Vessel_F_MEPcontent_Spirotech_SpiroExpand_EVN_INT-EN; Family and Type: HC_Expansion Vessel_F_MEPcontent_Spirotech_SpiroExpand_EVN_INT-EN: EVN3-80; Nipple 3/4" Safe: no; Nipple Connector: 0 mm; Reducing Nipple 3/4" – 1/2" Safe: no; Type: EVN3-80; Type Id: 1332240
Constraints - Elevation from Level: 0 mm
Dimensions - Area: 0.581353 m2; Volume: 0.0897403 m3
Identity Data - Mark: 4
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow: 0 m3/s
Phasing - Phase Created: 4. Plan over 10 jaar
Visibility - Nipple 3/4": no; Reducing Nipple 3/4" – 1/2": no

# IfcDistributionPort, InPort_1332273_1
Description: Flow; FlowDirection: SINK; PredefinedType: PIPE
